# Keil uVision project Motor_Control_V2.0.uvprojx, settings and files
target Motor_Control_V2.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Motor_Control_V2.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;../User/Command;../User/Drivers/current_sense;../User/Drivers/drv8870;../User/Utils;../User/ratation_control;../User/Drivers/motor_control;../User/Drivers/hall_speed;../User/Flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Users
    ../User/Command/: cmd_parser.h cmd_parser.c cmd_motor.h cmd_motor.c at_command.h at_command.c
    ../User/Drivers/current_sense/: currentsense.c currentsense.h
    ../User/Drivers/drv8870/: drv8870.c drv8870.h
    ../User/Utils/: log.c log.h
    ../User/ratation_control/: rotation_control.c rotation_control.h
    ../User/Drivers/motor_control/: motor_control.c motor_control.h
    ../User/Drivers/hall_speed/: speed_sensor.c speed_sensor.h
    ../User/Flash/: flash_storage.c flash_storage.h
software components: CMSIS:CORE 4.3.0
